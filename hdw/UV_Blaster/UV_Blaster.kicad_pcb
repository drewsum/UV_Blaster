# Repository drewsum/UV_Blaster (continued)

## KiCad design hdw/UV_Blaster/UV_Blaster.kicad_pcb (continued)

Schematic: UV_LEDs.sch, UV Blaster

Parts:
D1301, D1302, D1303, D1304, D1305, D1306, D1307, D1308, D1309, D1310, D1311, D1312, D1313, D1314, D1315, D1316, D1317, D1318, D1319, D1320, D1321, D1322, D1323, D1324, D1325, D1326, D1327, D1328, D1329, D1330, D1331, D1332, D1333, D1334, D1335, D1336: UV; LED_0603; Digi-Key PN 492-1949-1-ND

Connections:
unnamed: D1301.1 (K), D1307.2 (A)
unnamed: D1302.1 (K), D1308.2 (A)
unnamed: D1303.1 (K), D1309.2 (A)
unnamed: D1304.1 (K), D1310.2 (A)
unnamed: D1305.1 (K), D1311.2 (A)
unnamed: D1306.1 (K), D1312.2 (A)
unnamed: D1307.1 (K), D1313.2 (A)
unnamed: D1308.1 (K), D1314.2 (A)
unnamed: D1309.1 (K), D1315.2 (A)
unnamed: D1310.1 (K), D1316.2 (A)
unnamed: D1311.1 (K), D1317.2 (A)
unnamed: D1312.1 (K), D1318.2 (A)
unnamed: D1313.1 (K), D1319.2 (A)
unnamed: D1314.1 (K), D1320.2 (A)
unnamed: D1315.1 (K), D1321.2 (A)
unnamed: D1316.1 (K), D1322.2 (A)
unnamed: D1317.1 (K), D1323.2 (A)
unnamed: D1318.1 (K), D1324.2 (A)
unnamed: D1319.1 (K), D1325.2 (A)
unnamed: D1320.1 (K), D1326.2 (A)
unnamed: D1321.1 (K), D1327.2 (A)
unnamed: D1322.1 (K), D1328.2 (A)
unnamed: D1323.1 (K), D1329.2 (A)
unnamed: D1324.1 (K), D1330.2 (A)
unnamed: D1325.1 (K), D1331.2 (A)
unnamed: D1326.1 (K), D1332.2 (A)
unnamed: D1327.1 (K), D1333.2 (A)
unnamed: D1328.1 (K), D1334.2 (A)
unnamed: D1329.1 (K), D1335.2 (A)
unnamed: D1330.1 (K), D1336.2 (A)
VLED: D1301.2 (A), D1302.2 (A), D1303.2 (A), D1304.2 (A), D1305.2 (A), D1306.2 (A); also elsewhere on the board
~LED_SINK_0: D1331.1 (K); also elsewhere on the board
~LED_SINK_1: D1332.1 (K); also elsewhere on the board
~LED_SINK_2: D1333.1 (K); also elsewhere on the board
~LED_SINK_3: D1334.1 (K); also elsewhere on the board
~LED_SINK_4: D1335.1 (K); also elsewhere on the board
~LED_SINK_5: D1336.1 (K); also elsewhere on the board

Schematic: LED_Driver_Telemetry.sch, UV Blaster

Parts:
C1401, C1402, C1403, C1404, C1405: 0.1uF; C_0402; Voltage 50V; Digi-Key PN 490-10701-1-ND
DOC1401: 0x43
DOC1402: 0x1B
DOC1403: 0x44
U1401, U1403: INA219BxDCN; SOT-23-8; Digi-Key PN 296-46420-1-ND
U1402: MCP9804; DFN-8-1EP_3x2mm_P0.5mm_EP1.3x1.5mm; Digi-Key PN MCP9804T-E/MCCT-ND

Connections:
+5V: C1402.1, C1403.1, C1405.1, U1401.4 (VS), U1402.6 (A1), U1402.7 (A0), U1402.8 (VDD), U1403.4 (VS), U1403.8 (A1); also elsewhere on the board
GND: C1402.2, C1403.2, C1405.2, U1401.3 (GND), U1401.8 (A1), U1402.4 (GND), U1402.5 (A2), U1402.9 (EP/GND), U1403.3 (GND), U1403.7 (A0); also elsewhere on the board
I2C_SCL: U1401.5 (SCL), U1401.7 (A0), U1402.2 (SCL), U1403.5 (SCL); also elsewhere on the board
I2C_SDA: U1401.6 (SDA), U1402.1 (SDA), U1403.6 (SDA); also elsewhere on the board
VLED_SNS_IN+: C1401.1, U1401.1 (IN+); also elsewhere on the board
VLED_SNS_IN-: C1401.2, U1401.2 (IN-); also elsewhere on the board
VLED_SNS_OUT+: C1404.1, U1403.1 (IN+); also elsewhere on the board
VLED_SNS_OUT-: C1404.2, U1403.2 (IN-); also elsewhere on the board

Board: 4 copper layers, 241 parts (5 on the bottom side), 142 nets, no tracks yet.
